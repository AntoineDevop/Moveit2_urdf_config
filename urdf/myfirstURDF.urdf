Commit message: add python script

File: urdf/myfirstURDF.urdf (robot description, URDF)
Before this commit: robot myfirst, 4 links, 3 joints
Links:
- removed link origin
- removed link originX
- removed link originY
Joints:
- removed joint t_x
- removed joint t_y
- removed joint t_z
